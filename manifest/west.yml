## manifest/west.yml
```yaml
manifest:
  version: 0.8

  projects:
    - name: echo-colored-text
      url: https://github.com/bluccino/tool-ec.git
      path: deps/tool-ec
```
